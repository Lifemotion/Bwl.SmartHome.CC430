# IAR project WirelessDevices.ewp, settings and files
configuration Dongle (MSP430, debug)
  General.OGChipSelectMenu: CC430F5137 CC430F5137
  General.GStackSize2: 300
  General.GHeapSize2: 0
  General.RadioHeapSizeType: 0
  ICC430.CCDefines: MRFI_CC430
  ICC430.IExtraOptions: -f"Configuration\Dongle.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\drivers; Components\bsp\boards\CC430EM; Components\mrfi; D:\work\Other\CC430Devices\Devices.Fw\Components\simpliciti\nwk; D:\work\Other\CC430Devices\Devices.Fw\Components\simpliciti\nwk_applications; References
  ICC430.CCOptLevel: 1
  ICC430.CCOptStrategy: 0
  ICC430.IccLang: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\linker\lnkcc430f5137.xcl
  XLINK.XlinkStackSize: 1
configuration Smoke (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.IExtraOptions: -f"Configuration\Smoke.dat"; -f"Configuration\smpl_nwk_config.dat"
  ICC430.newCCIncludePaths: Components\bsp; Components\bsp\drivers; Components\bsp\boards\CC430EM; Components\mrfi; D:\work\Other\CC430Devices\Devices.Fw\Components\simpliciti\nwk_applications; References; D:\work\Other\CC430Devices\Devices.Fw\Components\simpliciti\nwk
configuration Leak (MSP430, debug)
  as the first configuration, except:
  General.RTConfigPath: $TOOLKIT_DIR$\lib\dlib\dl430xlsfn.h
  General.GStackSize2: 80
  General.GHeapSize2: 80
  ICC430.IExtraOptions: -f"Configuration\Leak.dat"; -f"Configuration\smpl_nwk_config.dat"
  group Applications
    Source/: device_radio_hal.c device_radio_hal.h
  group Applications/Dongle
    Source/: board_dongle.c board_dongle.h Dongle.c
    Configuration/: Dongle.dat
  group Applications/Leak
    Source/: Leak.c
    Configuration/: Leak.dat
  group Applications/Smoke
    Source/: Smoke.c
    Configuration/: Smoke.dat
  group References
    References/: sk_uart.c sk_uart.h
  group Stack/bsp
    Components/bsp/: bsp.c bsp.h bsp_macros.h
  group Stack/mrfi
    Components/mrfi/: mrfi.c mrfi.h mrfi_defs.h
  group Stack/nwk
    Components/simpliciti/nwk/: nv_obj.c nv_obj.h nwk.c nwk.h nwk_api.c nwk_api.h nwk_app.h nwk_frame.c nwk_frame.h nwk_globals.c nwk_globals.h nwk_QMgmt.c nwk_QMgmt.h nwk_types.h
  group Stack/nwk_applications
    Components/simpliciti/nwk_applications/: nwk_freq.c nwk_freq.h nwk_ioctl.c nwk_ioctl.h nwk_join.c nwk_join.h nwk_link.c nwk_link.h nwk_mgmt.c nwk_mgmt.h nwk_ping.c nwk_ping.h nwk_pll.c nwk_pll.h nwk_security.c nwk_security.h
